# Keil uVision project heroV1.0.uvprojx, settings and files
target heroV1.0 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: heroV1.0.elf +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,EMPL_TARGET_STM32F4,MPU6050
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Code/RTT/inc;../Code/eMPL/driver/eMPL;../Code/eMPL/driver/include;../Code/eMPL/driver/stm32L;../Code/eMPL/eMPL-hal;../Code/eMPL/mllite;../Code/eMPL/mpl;../Code/inc;..\Code\MadgwickAHRS;..\Code\MahonyAHRS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Code
    ../Code/src/: soft_iic.c mpu6050.c filter.c matrix.c Jscope.c imu.c function.c internal_flash.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group RTT
    ../Code/RTT/src/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group eMPL
    ../Code/eMPL/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Code/eMPL/driver/stm32L/: log_stm32.c
  group Mahony
    ../Code/MadgwickAHRS/: MadgwickAHRS.c
    ../Code/MahonyAHRS/: MahonyAHRS.c
software components: CMSIS:CORE 6.1.0
